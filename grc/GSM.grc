options:
  parameters:
    generate_options: qt_gui
    id: GSM
    output_language: python
  states: {}

blocks:
- name: Freq_GUI
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_index@0:1,1,1,2
    label: Frequency
    start: 925e6
    step: 200e3
    stop: 1.99e9
    value: 925e6
  states: {}
- name: Gain_GUI
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_index@0:0,1,1,1
    label: Gain
    start: '0'
    step: '0.5'
    stop: '50'
    value: '50'
  states: {}
- name: PPM_GUI
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_index@0:0,2,1,1
    label: PPM
    start: '-150'
    step: '1'
    stop: '150'
    value: '0'
  states: {}
- name: osr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592654'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: shiftoff
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2*pi*shiftoff/samp_rate'
  states: {}
- name: gsm_bcch_ccch_demapper_0
  id: gsm_bcch_ccch_demapper
  parameters:
    timeslot_nr: '0'
  states: {}
- name: gsm_clock_offset_control_0
  id: gsm_clock_offset_control
  parameters:
    fc: Freq_GUI-shiftoff
    osr: osr
    samp_rate: samp_rate
  states: {}
- name: gsm_control_channels_decoder_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_decryption_0
  id: gsm_decryption
  parameters:
    a5_version: '1'
    k_c: '[]'
  states: {}
- name: gsm_input_0
  id: gsm_input
  parameters:
    fc: Freq_GUI
    ppm: PPM_GUI
    samp_rate_in: samp_rate
  states: {}
- name: gsm_message_printer_0
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'False'
    prepend_frame_count: 'False'
    print_gsmtap_header: 'False'
  states: {}
- name: gsm_receiver_0
  id: gsm_receiver
  parameters:
    osr: '4'
  states: {}
- name: gsm_sdcch8_demapper_0
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '1'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4729'
    type: UDP_CLIENT
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab_index@0:2,1,2,2
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: 250e3+abs(shiftoff)
    corr0: PPM_GUI
    freq0: Freq_GUI-shiftoff
    gain0: Gain_GUI
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: tab_index
  id: qtgui_tab_widget
  parameters:
    label0: FFT
    label1: Waterfall
    num_tabs: '2'
  states: {}

connections:
- [blocks_rotator_cc_0, '0', gsm_input_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [gsm_bcch_ccch_demapper_0, bursts, gsm_control_channels_decoder_0, bursts]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0, ctrl_in]
- [gsm_control_channels_decoder_0, msgs, gsm_message_printer_0, msgs]
- [gsm_control_channels_decoder_0, msgs, network_socket_pdu_0, pdus]
- [gsm_control_channels_decoder_0_0, msgs, network_socket_pdu_0, pdus]
- [gsm_decryption_0, bursts, gsm_control_channels_decoder_0_0, bursts]
- [gsm_input_0, '0', gsm_receiver_0, '0']
- [gsm_receiver_0, C0, gsm_bcch_ccch_demapper_0, bursts]
- [gsm_receiver_0, C0, gsm_sdcch8_demapper_0, bursts]
- [gsm_receiver_0, measurements, gsm_clock_offset_control_0, measurements]
- [gsm_sdcch8_demapper_0, bursts, gsm_decryption_0, bursts]
- [rtlsdr_source_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
